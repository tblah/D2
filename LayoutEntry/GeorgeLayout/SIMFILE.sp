.lib "../libraries/amsc35b4.lib"
.include "TEAMG_RINGOSCILLATOR.spc"

Vgnd GND_GND 0V
Vsupply VDD GND 3.3V

VEN ENABLE GND
